`timescale 1ns / 1ps

module alu_TB;

    //====================================================
    // SEÑALES
    //====================================================

    reg [31:0] A;
    reg [31:0] B;

    reg alu_op;

    wire [31:0] result;

    //====================================================
    // DUT
    //====================================================

    alu DUT(
        .A(A),
        .B(B),
        .alu_op(alu_op),
        .result(result)
    );

    //====================================================
    // TESTS
    //====================================================

    initial begin

        //------------------------------------------------
        // INICIALIZACIÓN
        //------------------------------------------------

        A = 0;
        B = 0;

        alu_op = 0;

        //------------------------------------------------
        // TEST 1 : SUMA
        //------------------------------------------------

        $display("----- TEST 1 : SUMA -----");

        A = 32'd10;
        B = 32'd5;

        alu_op = 0;

        #1;

        if(result == 32'd15)
            $display("PASS");
        else
            $display("FAIL");

        //------------------------------------------------
        // TEST 2 : RESTA
        //------------------------------------------------

        $display("----- TEST 2 : RESTA -----");

        A = 32'd20;
        B = 32'd8;

        alu_op = 1;

        #1;

        if(result == 32'd12)
            $display("PASS");
        else
            $display("FAIL");

        //------------------------------------------------
        // TEST 3 : RESULTADO NEGATIVO
        //------------------------------------------------

        $display("----- TEST 3 : NEGATIVO -----");

        A = 32'd5;
        B = 32'd10;

        alu_op = 1;

        #1;

        if(result == (32'd5 - 32'd10))
            $display("PASS");
        else
            $display("FAIL");

        //------------------------------------------------
        // FIN SIMULACIÓN
        //------------------------------------------------

        #10;

        $finish;

    end

    //====================================================
    // WAVEFORMS
    //====================================================

    initial begin
        $dumpfile("alu_TB.vcd");
        $dumpvars(0, alu_TB);
    end

endmodule