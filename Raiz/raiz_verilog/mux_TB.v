`timescale 1ns / 1ps

module mux_TB;

    //====================================================
    // SEÑALES
    //====================================================

    reg [31:0] A;
    reg [31:0] B;
    reg [31:0] C;

    reg [1:0] sel;

    wire [31:0] Y;

    //====================================================
    // DUT
    //====================================================

    mux DUT(
        .A(A),
        .B(B),
        .C(C),
        .sel(sel),
        .Y(Y)
    );

    //====================================================
    // TESTS
    //====================================================

    initial begin

        //------------------------------------------------
        // INICIALIZACIÓN
        //------------------------------------------------

        A = 32'd10;
        B = 32'd20;
        C = 32'd30;

        sel = 2'b00;

        //------------------------------------------------
        // TEST 1 : SEL = 00
        //------------------------------------------------

        $display("----- TEST 1 : SEL = 00 -----");

        sel = 2'b00;

        #1;

        if(Y == 32'd10)
            $display("PASS");
        else
            $display("FAIL");

        //------------------------------------------------
        // TEST 2 : SEL = 01
        //------------------------------------------------

        $display("----- TEST 2 : SEL = 01 -----");

        sel = 2'b01;

        #1;

        if(Y == 32'd20)
            $display("PASS");
        else
            $display("FAIL");

        //------------------------------------------------
        // TEST 3 : SEL = 10
        //------------------------------------------------

        $display("----- TEST 3 : SEL = 10 -----");

        sel = 2'b10;

        #1;

        if(Y == 32'd30)
            $display("PASS");
        else
            $display("FAIL");

        //------------------------------------------------
        // TEST 4 : DEFAULT
        //------------------------------------------------

        $display("----- TEST 4 : DEFAULT -----");

        sel = 2'b11;

        #1;

        if(Y == 32'd0)
            $display("PASS");
        else
            $display("FAIL");

        //------------------------------------------------
        // FIN SIMULACIÓN
        //------------------------------------------------

        #10;

        $finish;

    end

    //====================================================
    // WAVEFORMS
    //====================================================

    initial begin
        $dumpfile("mux_TB.vcd");
        $dumpvars(0, mux_TB);
    end

endmodule