`timescale 1ns / 1ps

module comp_TB;

    //====================================================
    // SEÑALES
    //====================================================

    reg [31:0] A;
    reg [31:0] bit1;
    reg [31:0] temp;

    wire z;
    wire bit_gt_a;
    wire a_ge_temp;

    //====================================================
    // DUT
    //====================================================

    comp DUT(
        .A(A),
        .bit1(bit1),
        .temp(temp),
        .z(z),
        .bit_gt_a(bit_gt_a),
        .a_ge_temp(a_ge_temp)
    );

    //====================================================
    // TESTS
    //====================================================

    initial begin

        //------------------------------------------------
        // TEST 1 : bit1 == 0
        //------------------------------------------------

        $display("----- TEST 1 : bit1 == 0 -----");

        A     = 32'd20;
        bit1  = 32'd0;
        temp  = 32'd15;

        #1;

        if(z == 1'b1)
            $display("PASS");
        else
            $display("FAIL : z incorrect");

        //------------------------------------------------
        // TEST 2 : bit1 > A
        //------------------------------------------------

        $display("----- TEST 2 : bit1 > A -----");

        A     = 32'd20;
        bit1  = 32'd40;
        temp  = 32'd15;

        #1;

        if(bit_gt_a == 1'b1)
            $display("PASS");
        else
            $display("FAIL : bit_gt_a incorrect");

        //------------------------------------------------
        // TEST 3 : A >= temp
        //------------------------------------------------

        $display("----- TEST 3 : A >= temp -----");

        A     = 32'd50;
        bit1  = 32'd10;
        temp  = 32'd15;

        #1;

        if(a_ge_temp == 1'b1)
            $display("PASS");
        else
            $display("FAIL : a_ge_temp incorrect");

        //------------------------------------------------
        // TEST 4 : A < temp
        //------------------------------------------------

        $display("----- TEST 4 : A < temp -----");

        A     = 32'd5;
        bit1  = 32'd1;
        temp  = 32'd20;

        #1;

        if(a_ge_temp == 1'b0)
            $display("PASS");
        else
            $display("FAIL : a_ge_temp incorrect");

        //------------------------------------------------
        // FIN SIMULACIÓN
        //------------------------------------------------

        #2;

        $finish;

    end

    //====================================================
    // WAVEFORMS
    //====================================================

    initial begin
        $dumpfile("comp_TB.vcd");
        $dumpvars(0, comp_TB);
    end

endmodule